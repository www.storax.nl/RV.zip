Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 2e164bc4-2c3a-456c-a652-ffecd7854d51.ifc
Time: 2026-09-11T16:00:21
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - HagoDeck RV 86, 600x800mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAFuCurYDAAAArowAAAV2SgAA2FMBAFJfAQDxgwAA-84AAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAFuCurYDAAAArowAAAV2SgAA2FMBAFJfAQDxgwAA-84AAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 37 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 705 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 905 mm; Rc-waarde: 0 m²·k/w; serie: HagoDeck; afsluitbaar: True; hoogte: 60 mm; merk: Storax; breuklast: A15; type: RV 86; dagmaatbreedte: 800 mm; omranding: staal; luik: staal
