Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 33918bf9-c8fb-4125-a9af-e9d711e30b5c.ifc
Time: 2026-09-11T15:59:47
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - HagoDeck RV 64, 600x400mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAFvPi7YDAAAArowAAAV2SgAA2FMBAFJfAQDxgwAAtv8AAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAFvPi7YDAAAArowAAAV2SgAA2FMBAFJfAQDxgwAAtv8AAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 22 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 705 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 505 mm; Rc-waarde: 0 m²·k/w; serie: HagoDeck; afsluitbaar: True; hoogte: 60 mm; merk: Storax; breuklast: A15; type: RV 64; dagmaatbreedte: 400 mm; omranding: staal; luik: staal
